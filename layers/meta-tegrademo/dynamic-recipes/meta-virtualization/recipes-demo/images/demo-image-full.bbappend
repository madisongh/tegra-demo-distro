require demo-image-docker-minimal.inc
