inherit tegrasign
