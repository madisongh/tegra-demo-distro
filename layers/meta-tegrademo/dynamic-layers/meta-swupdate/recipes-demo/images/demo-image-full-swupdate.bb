require swupdate-image-tegra-common.inc
