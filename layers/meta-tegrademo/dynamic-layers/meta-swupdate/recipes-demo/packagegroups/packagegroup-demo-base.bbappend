RDEPENDS:${PN} += "swupdate"
